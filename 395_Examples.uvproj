# Keil uVision project 395_Examples.uvproj, settings and files
target Examples (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1114/102 NXP
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: 395_Examples
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Startup
    ./: startup_LPC11xx.s system_LPC11xx.c
  group PWM
    ./: PWM_32bit_Timer.c PWM_32bit_Timer.h PWM_16bit_Timer.c PWM_16bit_Timer.h
  group Main
    ./: main.c
  group UART
    ./: Serial.c Serial.h Retarget.c
  group I2C
    ./: I2C.c I2C.h
  group SPI
    ./: SPI.c SPI.h
